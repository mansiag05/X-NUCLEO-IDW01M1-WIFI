# Keil uVision project mbed-os-example-client.uvprojx, settings and files
target mbed-os-example-client (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  output: mbed-os-example-client
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DTARGET_NUCLEO_F401RE -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DMBED_BUILD_TIMESTAMP=1478080896.49 --restrict -DTARGET_STM32F4 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -DFEATURE_LOWPAN_ROUTER=1 -DTARGET_FF_MORPHO -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -O3 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_SERIAL_ASYNCH=1 --split_sections --multibyte_chars --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DDEVICE_ANALOGIN=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DARM_MATH_CM4 -DDEVICE_I2C=1 -DDEVICE_PORTIN=1 -DTARGET_STM --brief_diagnostics -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DTARGET_STM32F401RE -DFEATURE_COMMON_PAL=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SERIAL_FC=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM -DFEATURE_NANOSTACK=1
  c include: .;.\atmel-rf-driver;.\atmel-rf-driver\atmel-rf-driver;.\atmel-rf-driver\source;.\docs;.\docs\img;.\GW_Binary;.\mbed-client;.\mbed-client\mbed-client;.\mbed-client\mbed-client-classic;.\mbed-client\mbed-client-classic\mbed-client-classic;.\mbed-client\mbed-client-classic\source;.\mbed-client\mbed-client-mbed-tls;.\mbed-client\mbed-client-mbed-tls\mbed-client-mbedtls;.\mbed-client\mbed-client-mbed-tls\source;.\mbed-client\source;.\mbed-client\source\include;.\mbed-os;.\mbed-os\cmsis;.\mbed-os\docs;.\mbed-os\drivers;.\mbed-os\events;.\mbed-os\events\equeue;.\mbed-os\features;.\mbed-os\features\frameworks;.\mbed-os\features\frameworks\greentea-client;.\mbed-os\features\frameworks\greentea-client\greentea-client;.\mbed-os\features\frameworks\greentea-client\source;.\mbed-os\features\frameworks\unity;.\mbed-os\features\frameworks\unity\source;.\mbed-os\features\frameworks\unity\unity;.\mbed-os\features\frameworks\utest;.\mbed-os\features\frameworks\utest\source;.\mbed-os\features\frameworks\utest\utest;.\mbed-os\features\mbedtls;.\mbed-os\features\mbedtls\importer;.\mbed-os\features\mbedtls\inc;.\mbed-os\features\mbedtls\inc\mbedtls;.\mbed-os\features\mbedtls\platform;.\mbed-os\features\mbedtls\platform\inc;.\mbed-os\features\mbedtls\platform\src;.\mbed-os\features\mbedtls\src;.\mbed-os\features\nanostack;.\mbed-os\features\netsocket;.\mbed-os\features\storage;.\mbed-os\hal;.\mbed-os\hal\hal;.\mbed-os\hal\storage_abstraction;.\mbed-os\platform;.\mbed-os\rtos;.\mbed-os\rtos\rtx;.\mbed-os\rtos\rtx\TARGET_CORTEX_M;.\mbed-os\rtos\rtx\TARGET_CORTEX_M\TARGET_RTOS_M4_M7;.\mbed-os\rtos\rtx\TARGET_CORTEX_M\TARGET_RTOS_M4_M7\TOOLCHAIN_ARM;.\mbed-os\targets;.\mbed-os\targets\TARGET_STM;.\mbed-os\targets\TARGET_STM\TARGET_STM32F4;.\mbed-os\targets\TARGET_STM\TARGET_STM32F4\device;.\mbed-os\targets\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F401RE;.\mbed-os\targets\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F401RE\device;.\mbed-os\targets\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F401RE\device\TOOLCHAIN_ARM_STD;.\mcr20a-rf-driver;.\mcr20a-rf-driver\mcr20a-rf-driver;.\mcr20a-rf-driver\source;.\pal;.\pal\Source;.\pal\Source\PAL-Impl;.\pal\Source\PAL-Impl\Modules;.\pal\Source\PAL-Impl\Modules\Networking;.\pal\Source\PAL-Impl\Modules\RTOS;.\pal\Source\PAL-Impl\Modules\Update;.\pal\Source\PAL-Impl\Services-API;.\pal\Source\Port;.\pal\Source\Port\Platform-API;.\pal\Source\Port\Reference-Impl;.\pal\Source\Port\Reference-Impl\mbedOS;.\pal\Source\Port\Reference-Impl\mbedOS\Networking;.\pal\Source\Port\Reference-Impl\mbedOS\RTOS;.\mbed-os\features\FEATURE_COMMON_PAL;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\doxygen;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\nsdl-c;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libCoap;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libCoap\src;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libCoap\src\include;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libNsdl;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libNsdl\src;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-c\source\libNsdl\src\include;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-randlib;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-randlib\mbed-client-randlib;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-randlib\mbed-client-randlib\platform;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-client-randlib\source;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-trace;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-trace\mbed-trace;.\mbed-os\features\FEATURE_COMMON_PAL\mbed-trace\source;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-hal-mbed-cmsis-rtos;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-hal-mbed-cmsis-rtos\cs_nvm;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-hal-mbed-cmsis-rtos\nvm;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\mbed-client-libservice;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\mbed-client-libservice\platform;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\IPv6_fcf_lib;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\libBits;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\libip6string;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\libList;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\libTrace;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\libTrace\scripts;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\nsdynmemLIB;.\mbed-os\features\FEATURE_COMMON_PAL\nanostack-libservice\source\nvmHelper;.\mbed-os\features\FEATURE_COMMON_PAL\sal-stack-nanostack-eventloop;.\mbed-os\features\FEATURE_COMMON_PAL\sal-stack-nanostack-eventloop\nanostack-event-loop;.\mbed-os\features\FEATURE_COMMON_PAL\sal-stack-nanostack-eventloop\nanostack-event-loop\platform;.\mbed-os\features\FEATURE_COMMON_PAL\sal-stack-nanostack-eventloop\source;.\mbed-os\features\nanostack\FEATURE_LOWPAN_ROUTER;.\mbed-os\features\nanostack\FEATURE_LOWPAN_ROUTER\TOOLCHAIN_ARM;.\mbed-os\features\nanostack\FEATURE_LOWPAN_ROUTER\TOOLCHAIN_ARM\TARGET_RTOS_M4_M7;.\mbed-os\features\nanostack\FEATURE_NANOSTACK;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\coap-service;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\coap-service\coap-service;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\coap-service\source;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\coap-service\source\include;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\mbed-mesh-api;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\mbed-mesh-api\mbed-mesh-api;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\mbed-mesh-api\source;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\mbed-mesh-api\source\include;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\nanostack-interface;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack\docs;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack\docs\img;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack\doxygen;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack\nanostack;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\sal-stack-nanostack\nanostack\platform;.\mbed-os\features\nanostack\FEATURE_NANOSTACK\targets;.\x-nucleo-idw01m1;.\x-nucleo-idw01m1\SPWF01SA;.\x-nucleo-idw01m1\SPWF01SA\ATParser;.\x-nucleo-idw01m1\SPWF01SA\ATParser\BufferedSerial;.\x-nucleo-idw01m1\SPWF01SA\ATParser\BufferedSerial\Buffer
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M4,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: .\mbed-os\targets\TARGET_STM\TARGET_STM32F4\TARGET_NUCLEO_F401RE\device\TOOLCHAIN_ARM_STD\stm32f401xe.sct
  group Networking
    ./pal/Source/PAL-Impl/Modules/Networking/: pal_network.c
    ./pal/Source/Port/Reference-Impl/mbedOS/Networking/: pal_plat_network.cpp
  group cs_nvm
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
  group rtos
    ./mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h rtos.h RtosTimer.h rtos_idle.h Semaphore.h Thread.h rtos_idle.c Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group cmsis
    ./mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group nanostack
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack/: cca_api.h ccmLIB.h dev_stat_api.h dhcp_service_api.h ethernet_mac_api.h mac_api.h mac_common_defines.h mac_filter_api.h mac_mcps.h mlme.h multicast_api.h net_6lowpan_parameter_api.h net_address_extension.h net_fhss.h net_interface.h net_ipv6_api.h net_mle_api.h net_nvm_api.h net_nwk_scan.h net_pana_parameters_api.h net_polling_api.h net_rpl.h net_sleep.h net_thread_test.h ns_address.h ns_sha256.h ns_virtual_rf_api.h nwk_stats_api.h serial_mac_api.h shalib.h socket_api.h sw_mac.h thread_border_router_api.h thread_commissioning_api.h thread_dhcpv6_server.h thread_diagcop_lib.h thread_management_api.h thread_management_if.h thread_meshcop_lib.h thread_net_config_api.h whiteboard_api.h
  group nvmHelper
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
  group TARGET_NUCLEO_F401RE
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/: objects.h PeripheralNames.h PinNames.h PortNames.h PeripheralPins.c
  group TARGET_RTOS_M4_M7
    ./mbed-os/features/nanostack/FEATURE_LOWPAN_ROUTER/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: libnanostack_armcc_Cortex-M3_lowpan_router.ar
  group mbed-mesh-api
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/mbed-mesh-api/: AbstractMesh.h AbstractNetworkInterface.h Mesh6LoWPAN_ND.h MeshInterfaceFactory.h MeshThread.h mesh_interface_types.h
  group Services-API
    ./pal/Source/PAL-Impl/Services-API/: pal.h pal_configuration.h pal_errors.h pal_macros.h pal_network.h pal_rtos.h pal_types.h
  group nanostack-event-loop
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
  group platform
    ./mbed-os/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_wait_api_no_rtos.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/sal-stack-nanostack/nanostack/platform/: arm_hal_aes.h arm_hal_phy.h os_whiteboard.h topo_trace.h
  group TARGET_STM32F4
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/: common_objects.h device.h gpio_object.h PeripheralPins.h rtc_api_hal.h analogin_api.c analogout_api.c can_api.c gpio_api.c gpio_irq_api.c i2c_api.c lp_ticker.c mbed_overrides.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group atmel-rf-driver
    ./atmel-rf-driver/atmel-rf-driver/: NanostackRfPhyAtmel.h
  group mbed-client-randlib
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/mbed-client-randlib/: randLIB.h
  group Platform-API
    ./pal/Source/Port/Platform-API/: pal_plat_network.h pal_plat_rtos.h
  group IPv6_fcf_lib
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
  group utest
    ./mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    ./mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
  group hal
    ./mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
    ./mbed-os/hal/hal/: emac_api.h
  group netsocket
    ./mbed-os/features/netsocket/: CellularInterface.h emac_stack_mem.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h nsapi.h nsapi_dns.h nsapi_types.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h NetworkInterface.cpp NetworkStack.cpp nsapi_dns.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp
  group TARGET_CORTEX_M
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h RTX_CM_lib.h RTX_Config.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Memory.h rt_Mutex.h rt_OsEventObserver.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group greentea-client
    ./mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
  group unity
    ./mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group equeue
    ./mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
  group nsdl-c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/nsdl-c/: sn_coap_header.h sn_coap_protocol.h sn_config.h sn_nsdl.h sn_nsdl_lib.h
  group include
    ./mbed-client/source/include/: eventdata.h m2minterfaceimpl.h m2mnsdlinterface.h m2mnsdlobserver.h m2mreporthandler.h m2mtlvdeserializer.h m2mtlvserializer.h nsdlaccesshelper.h nsdllinker.h smartpointer.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/include/: sn_grs.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source/include/: coap_connection_handler.h coap_message_handler.h coap_security_handler.h coap_service_api_internal.h
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source/include/: callback_handler.h mesh_system.h nd_tasklet.h static_config.h thread_tasklet.h
  group mbedtls
    ./mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pkcs11.h pkcs12.h pkcs5.h pk_internal.h platform.h platform_time.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group mbed-client-classic
    ./mbed-client/mbed-client-classic/mbed-client-classic/: m2mconnectionhandlerpimpl.h m2mtimerpimpl.h
  group nsdynmemLIB
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
  group nanostack-interface
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/nanostack-interface/: NanostackInterface.h NanostackRfPhy.h NanostackInterface.cpp
  group libTrace
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libTrace/: ns_trace.c
  group events
    ./mbed-os/events/: Event.h EventQueue.h mbed_events.h EventQueue.cpp
  group libip6string
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
  group mbed-os-example-client
    ./: mbed_config.h mbedtls_mbed_client_config.h mbed_client_config.h security.h simpleclient.h main.cpp
  group nanostack-hal-mbed-cmsis-rtos
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt_private.h ns_event_loop.h ns_hal_init.h arm_hal_interrupt.c arm_hal_random.c ns_event_loop.c ns_hal_init.c arm_hal_timer.cpp
  group mbed-os
    ./mbed-os/: mbed.h
  group libBits
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libBits/: common_functions.c
  group TARGET_STM
    ./mbed-os/targets/TARGET_STM/: mbed_rtx.h stm_spi_api.c trng_api.c
  group mbed-client-libservice
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h nsdynmemLIB.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h
  group mbed-trace
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/mbed-trace/: mbed_trace.h
  group device
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/device/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h stm32_hal_legacy.h stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32f401xe.h stm32f4xx.h stm32f4xx_hal_conf.h system_stm32f4xx.h cmsis_nvic.c hal_tick.c system_stm32f4xx.c
  group nvm
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
  group mbed-client-mbedtls
    ./mbed-client/mbed-client-mbed-tls/mbed-client-mbedtls/: m2mconnectionsecuritypimpl.h
  group coap-service
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/coap-service/: coap_service_api.h
  group src
    ./mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    ./mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libCoap/src/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-c/source/libNsdl/src/: sn_grs.c sn_nsdl.c
  group PAL-Impl
    ./pal/Source/PAL-Impl/: pal_init.c
  group mcr20a-rf-driver
    ./mcr20a-rf-driver/mcr20a-rf-driver/: NanostackRfPhyMcr20a.h
  group libList
    ./mbed-os/features/FEATURE_COMMON_PAL/nanostack-libservice/source/libList/: ns_list.c
  group RTOS
    ./pal/Source/PAL-Impl/Modules/RTOS/: pal_rtos.c
    ./pal/Source/Port/Reference-Impl/mbedOS/RTOS/: pal_plat_rtos.c
  group mbed-client
    ./mbed-client/mbed-client/: functionpointer.h m2mbase.h m2mblockmessage.h m2mconfig.h m2mconnectionhandler.h m2mconnectionobserver.h m2mconnectionsecurity.h m2mconstants.h m2mdevice.h m2mfirmware.h m2minterface.h m2minterfacefactory.h m2minterfaceobserver.h m2mobject.h m2mobjectinstance.h m2mobservationhandler.h m2mreportobserver.h m2mresource.h m2mresourceinstance.h m2msecurity.h m2mserver.h m2mstring.h m2mtimer.h m2mtimerobserver.h m2mvector.h
  group drivers
    ./mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp Serial.cpp SerialBase.cpp SPI.cpp SPISlave.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group storage_abstraction
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group source
    ./atmel-rf-driver/source/: at24mac.h AT86RFReg.h at24mac.cpp NanostackRfPhyAtmel.cpp
    ./mcr20a-rf-driver/source/: MCR20Drv.h MCR20Overwrites.h MCR20Reg.h XcvrSpi.h MCR20Drv.c NanostackRfPhyMcr20a.cpp
    ./mbed-os/features/FEATURE_COMMON_PAL/sal-stack-nanostack-eventloop/source/: ns_timer.h timer_sys.h event.c ns_timer.c system_timer.c timeout.c minar_hal_timer.cpp
    ./mbed-os/features/frameworks/unity/source/: unity.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-client-randlib/source/: randLIB.c
    ./mbed-os/features/FEATURE_COMMON_PAL/mbed-trace/source/: mbed_trace.c
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/coap-service/source/: coap_connection_handler.c coap_message_handler.c coap_security_handler.c coap_service_api.c
    ./mbed-os/features/nanostack/FEATURE_NANOSTACK/mbed-mesh-api/source/: mesh_system.c nd_tasklet.c thread_tasklet.c to_be_ported.c AbstractMesh.cpp AbstractNetworkInterface.cpp CallbackHandler.cpp Mesh6LoWPAN_ND.cpp MeshInterfaceFactory.cpp MeshThread.cpp
    ./mbed-client/mbed-client-classic/source/: m2mconnectionhandler.cpp m2mconnectionhandlerpimpl.cpp m2mtimer.cpp m2mtimerpimpl.cpp
    ./mbed-client/mbed-client-mbed-tls/source/: m2mconnectionsecurity.cpp m2mconnectionsecuritypimpl.cpp
    ./mbed-client/source/: m2mbase.cpp m2mblockmessage.cpp m2mdevice.cpp m2mfirmware.cpp m2minterfacefactory.cpp m2minterfaceimpl.cpp m2mnsdlinterface.cpp m2mobject.cpp m2mobjectinstance.cpp m2mreporthandler.cpp m2mresource.cpp m2mresourceinstance.cpp m2msecurity.cpp m2mserver.cpp m2mstring.cpp m2mtlvdeserializer.cpp m2mtlvserializer.cpp nsdlaccesshelper.cpp
    ./mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp test_env.cpp
    ./mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
  group TOOLCHAIN_ARM
    ./mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM4.c
  group inc
    ./mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group TOOLCHAIN_ARM_STD
    ./mbed-os/targets/TARGET_STM/TARGET_STM32F4/TARGET_NUCLEO_F401RE/device/TOOLCHAIN_ARM_STD/: startup_stm32f401xe.S sys.cpp
  group x-nucleo-idw01m1
    ./x-nucleo-idw01m1/: SpwfInterface.cpp SpwfInterface.h
  group SPWF01SA
    ./x-nucleo-idw01m1/SPWF01SA/: SPWFSA01.cpp SPWFSA01.h
  group ATParser
    ./x-nucleo-idw01m1/SPWF01SA/ATParser/: ATParser.cpp ATParser.h
  group BufferedSerial
    ./x-nucleo-idw01m1/SPWF01SA/ATParser/BufferedSerial/: BufferedPrint.c BufferedSerial.cpp BufferedSerial.h
  group Buffer
    ./x-nucleo-idw01m1/SPWF01SA/ATParser/BufferedSerial/Buffer/: MyBuffer.cpp MyBuffer.h
